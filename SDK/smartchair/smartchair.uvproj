# Keil uVision project smartchair.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: smartchair +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver
  group Source Group 1
    ./driver/: oled.c adc.c uart.c key.c e2prom.c tof10120.c timer.c menu.c Menufun.c
    ./: main.c
